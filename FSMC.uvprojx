# Keil uVision project FSMC.uvprojx, settings and files
target FSMC (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FSMC
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\hardware\lcd;.\user;.\RTE;.\hardware\system\delay;.\hardware\system\sys;.\hardware\system\usart;.\hardware\timer;.\emwin\STemWinLibrary522\Config;.\emwin\STemWinLibrary522\inc;.\emwin\STemWinLibrary522\Lib;.\emwin\STemWinLibrary522\OS;.\emwin\Demo;.\hardware\touch;.\hardware\SPI;.\hardware\flash;.\emwin\Font;.\APP;.\APP\UI;.\user\malloc;.\ucos_ii\CONFIG;.\ucos_ii\PORTS;.\ucos_ii\SOURCE;.\hardware\ADC_DMA;.\DSP_lib\STM32F10x_DSP_Lib\inc;.\DSP_lib\STM32F10x_DSP_Lib\src\asm\arm;.\hardware\key
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c display.c voice.c
  group hardware
    ./hardware/lcd/: LCD_Driver.c lcd_ex.c
    ./hardware/system/delay/: delay.c
    ./hardware/system/sys/: sys.c
    ./hardware/system/usart/: usart.c
    ./hardware/timer/: timer.c
    ./hardware/ADC_DMA/: ADC_DMA.c
    ./hardware/key/: key.c
  group DSP_lib
    ./DSP_lib/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s
    ./DSP_lib/STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
software components: CMSIS:CORE 4.3.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
